v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {DAC_Mux2: generated from the LTspice schematic by tools/gen_xschem.py} -900 -560 0 0 0.4 0.4 {}
C {devices/ipin.sym} -900 -500 0 0 {name=p1 lab=A}
C {devices/ipin.sym} -900 -470 0 0 {name=p2 lab=B}
C {devices/ipin.sym} -900 -440 0 0 {name=p3 lab=S}
C {devices/ipin.sym} -900 -410 0 0 {name=p4 lab=SB}
C {devices/iopin.sym} -900 -380 0 0 {name=p5 lab=VDD}
C {devices/iopin.sym} -900 -350 0 0 {name=p6 lab=VSS}
C {devices/opin.sym} -900 -320 0 0 {name=p7 lab=Y}
C {CMOS_TG.sym} -500 -400 0 0 {name=xXTG0}
C {devices/lab_pin.sym} -590.0 -420.0 0 0 {name=l1 sig_type=std_logic lab=A}
C {devices/lab_pin.sym} -410.0 -420.0 0 0 {name=l2 sig_type=std_logic lab=Y}
C {devices/lab_pin.sym} -590.0 -400.0 0 0 {name=l3 sig_type=std_logic lab=SB}
C {devices/lab_pin.sym} -590.0 -380.0 0 0 {name=l4 sig_type=std_logic lab=S}
C {devices/lab_pin.sym} -410.0 -400.0 0 0 {name=l5 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -410.0 -380.0 0 0 {name=l6 sig_type=std_logic lab=VSS}
C {CMOS_TG.sym} -180 -400 0 0 {name=xXTG1}
C {devices/lab_pin.sym} -270.0 -420.0 0 0 {name=l7 sig_type=std_logic lab=B}
C {devices/lab_pin.sym} -90.0 -420.0 0 0 {name=l8 sig_type=std_logic lab=Y}
C {devices/lab_pin.sym} -270.0 -400.0 0 0 {name=l9 sig_type=std_logic lab=S}
C {devices/lab_pin.sym} -270.0 -380.0 0 0 {name=l10 sig_type=std_logic lab=SB}
C {devices/lab_pin.sym} -90.0 -400.0 0 0 {name=l11 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -90.0 -380.0 0 0 {name=l12 sig_type=std_logic lab=VSS}
