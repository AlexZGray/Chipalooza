v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {Sky_OTA: generated from the LTspice schematic by tools/gen_xschem.py} -900 -560 0 0 0.4 0.4 {}
C {devices/ipin.sym} -900 -500 0 0 {name=p1 lab=INP}
C {devices/ipin.sym} -900 -470 0 0 {name=p2 lab=INM}
C {devices/iopin.sym} -900 -440 0 0 {name=p3 lab=VDD}
C {devices/iopin.sym} -900 -410 0 0 {name=p4 lab=VSS}
C {devices/iopin.sym} -900 -380 0 0 {name=p5 lab=IBIAS}
C {devices/opin.sym} -900 -350 0 0 {name=p6 lab=OUT}
C {Sky_Bias.sym} -500 -400 0 0 {name=xXBIAS}
C {devices/lab_pin.sym} -410.0 -430.0 0 0 {name=l1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -410.0 -410.0 0 0 {name=l2 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -410.0 -390.0 0 0 {name=l3 sig_type=std_logic lab=IBIAS}
C {devices/lab_pin.sym} -410.0 -370.0 0 0 {name=l4 sig_type=std_logic lab=BP}
C {Sky_InputP.sym} -180 -400 0 0 {name=xXPIN}
C {devices/lab_pin.sym} -270.0 -420.0 0 0 {name=l5 sig_type=std_logic lab=INP}
C {devices/lab_pin.sym} -270.0 -400.0 0 0 {name=l6 sig_type=std_logic lab=INM}
C {devices/lab_pin.sym} -90.0 -420.0 0 0 {name=l7 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -90.0 -400.0 0 0 {name=l8 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -270.0 -380.0 0 0 {name=l9 sig_type=std_logic lab=BP}
C {devices/lab_pin.sym} -90.0 -380.0 0 0 {name=l10 sig_type=std_logic lab=G2}
C {Sky_InputN.sym} 140 -400 0 0 {name=xXNIN}
C {devices/lab_pin.sym} 50.0 -430.0 0 0 {name=l11 sig_type=std_logic lab=INP}
C {devices/lab_pin.sym} 50.0 -410.0 0 0 {name=l12 sig_type=std_logic lab=INM}
C {devices/lab_pin.sym} 230.0 -430.0 0 0 {name=l13 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 230.0 -410.0 0 0 {name=l14 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 230.0 -390.0 0 0 {name=l15 sig_type=std_logic lab=IBIAS}
C {devices/lab_pin.sym} 230.0 -370.0 0 0 {name=l16 sig_type=std_logic lab=G2}
C {Sky_Output.sym} 460 -400 0 0 {name=xXOUTPUT}
C {devices/lab_pin.sym} 370.0 -420.0 0 0 {name=l17 sig_type=std_logic lab=G2}
C {devices/lab_pin.sym} 370.0 -400.0 0 0 {name=l18 sig_type=std_logic lab=BP}
C {devices/lab_pin.sym} 550.0 -420.0 0 0 {name=l19 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 550.0 -400.0 0 0 {name=l20 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 550.0 -380.0 0 0 {name=l21 sig_type=std_logic lab=OUT}
