v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {DAC6_Sky130_Core: generated from the LTspice schematic by tools/gen_xschem.py} -900 -560 0 0 0.4 0.4 {}
C {devices/ipin.sym} -900 -500 0 0 {name=p1 lab=D0}
C {devices/ipin.sym} -900 -470 0 0 {name=p2 lab=D1}
C {devices/ipin.sym} -900 -440 0 0 {name=p3 lab=D2}
C {devices/ipin.sym} -900 -410 0 0 {name=p4 lab=D3}
C {devices/ipin.sym} -900 -380 0 0 {name=p5 lab=D4}
C {devices/ipin.sym} -900 -350 0 0 {name=p6 lab=D5}
C {devices/ipin.sym} -900 -320 0 0 {name=p7 lab=EN}
C {devices/iopin.sym} -900 -290 0 0 {name=p8 lab=VDDA}
C {devices/iopin.sym} -900 -260 0 0 {name=p9 lab=VSS}
C {devices/iopin.sym} -900 -230 0 0 {name=p10 lab=VREFL}
C {devices/iopin.sym} -900 -200 0 0 {name=p11 lab=VREFH}
C {devices/iopin.sym} -900 -170 0 0 {name=p12 lab=IBIAS}
C {devices/opin.sym} -900 -140 0 0 {name=p13 lab=VTAP}
C {devices/opin.sym} -900 -110 0 0 {name=p14 lab=VOUT}
C {DAC_Control.sym} -500 -400 0 0 {name=xXCONTROL}
C {devices/lab_pin.sym} -590.0 -550.0 0 0 {name=l1 sig_type=std_logic lab=D0}
C {devices/lab_pin.sym} -590.0 -530.0 0 0 {name=l2 sig_type=std_logic lab=D1}
C {devices/lab_pin.sym} -590.0 -510.0 0 0 {name=l3 sig_type=std_logic lab=D2}
C {devices/lab_pin.sym} -590.0 -490.0 0 0 {name=l4 sig_type=std_logic lab=D3}
C {devices/lab_pin.sym} -590.0 -470.0 0 0 {name=l5 sig_type=std_logic lab=D4}
C {devices/lab_pin.sym} -590.0 -450.0 0 0 {name=l6 sig_type=std_logic lab=D5}
C {devices/lab_pin.sym} -590.0 -430.0 0 0 {name=l7 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} -410.0 -550.0 0 0 {name=l8 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} -410.0 -530.0 0 0 {name=l9 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -410.0 -510.0 0 0 {name=l10 sig_type=std_logic lab=S0}
C {devices/lab_pin.sym} -410.0 -490.0 0 0 {name=l11 sig_type=std_logic lab=S0B}
C {devices/lab_pin.sym} -410.0 -470.0 0 0 {name=l12 sig_type=std_logic lab=S1}
C {devices/lab_pin.sym} -410.0 -450.0 0 0 {name=l13 sig_type=std_logic lab=S1B}
C {devices/lab_pin.sym} -410.0 -430.0 0 0 {name=l14 sig_type=std_logic lab=S2}
C {devices/lab_pin.sym} -410.0 -410.0 0 0 {name=l15 sig_type=std_logic lab=S2B}
C {devices/lab_pin.sym} -410.0 -390.0 0 0 {name=l16 sig_type=std_logic lab=S3}
C {devices/lab_pin.sym} -410.0 -370.0 0 0 {name=l17 sig_type=std_logic lab=S3B}
C {devices/lab_pin.sym} -410.0 -350.0 0 0 {name=l18 sig_type=std_logic lab=S4}
C {devices/lab_pin.sym} -410.0 -330.0 0 0 {name=l19 sig_type=std_logic lab=S4B}
C {devices/lab_pin.sym} -410.0 -310.0 0 0 {name=l20 sig_type=std_logic lab=S5}
C {devices/lab_pin.sym} -410.0 -290.0 0 0 {name=l21 sig_type=std_logic lab=S5B}
C {devices/lab_pin.sym} -410.0 -270.0 0 0 {name=l22 sig_type=std_logic lab=E}
C {devices/lab_pin.sym} -410.0 -250.0 0 0 {name=l23 sig_type=std_logic lab=EB}
C {DAC_String64.sym} -180 -400 0 0 {name=xXSTRING}
C {devices/lab_pin.sym} -86.0 -510.0 0 0 {name=l24 sig_type=std_logic lab=VREFL}
C {devices/lab_pin.sym} -86.0 -490.0 0 0 {name=l25 sig_type=std_logic lab=VREFH}
C {devices/lab_pin.sym} -274.0 -510.0 0 0 {name=l26 sig_type=std_logic lab=S0}
C {devices/lab_pin.sym} -274.0 -490.0 0 0 {name=l27 sig_type=std_logic lab=S0B}
C {devices/lab_pin.sym} -274.0 -470.0 0 0 {name=l28 sig_type=std_logic lab=S1}
C {devices/lab_pin.sym} -274.0 -450.0 0 0 {name=l29 sig_type=std_logic lab=S1B}
C {devices/lab_pin.sym} -274.0 -430.0 0 0 {name=l30 sig_type=std_logic lab=S2}
C {devices/lab_pin.sym} -274.0 -410.0 0 0 {name=l31 sig_type=std_logic lab=S2B}
C {devices/lab_pin.sym} -274.0 -390.0 0 0 {name=l32 sig_type=std_logic lab=S3}
C {devices/lab_pin.sym} -274.0 -370.0 0 0 {name=l33 sig_type=std_logic lab=S3B}
C {devices/lab_pin.sym} -274.0 -350.0 0 0 {name=l34 sig_type=std_logic lab=S4}
C {devices/lab_pin.sym} -274.0 -330.0 0 0 {name=l35 sig_type=std_logic lab=S4B}
C {devices/lab_pin.sym} -274.0 -310.0 0 0 {name=l36 sig_type=std_logic lab=S5}
C {devices/lab_pin.sym} -274.0 -290.0 0 0 {name=l37 sig_type=std_logic lab=S5B}
C {devices/lab_pin.sym} -86.0 -470.0 0 0 {name=l38 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} -86.0 -450.0 0 0 {name=l39 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -86.0 -430.0 0 0 {name=l40 sig_type=std_logic lab=VTAP}
C {DAC_Mux2.sym} 140 -400 0 0 {name=xXENABLE}
C {devices/lab_pin.sym} 50.0 -430.0 0 0 {name=l41 sig_type=std_logic lab=VREFL}
C {devices/lab_pin.sym} 50.0 -410.0 0 0 {name=l42 sig_type=std_logic lab=VTAP}
C {devices/lab_pin.sym} 50.0 -390.0 0 0 {name=l43 sig_type=std_logic lab=E}
C {devices/lab_pin.sym} 50.0 -370.0 0 0 {name=l44 sig_type=std_logic lab=EB}
C {devices/lab_pin.sym} 230.0 -430.0 0 0 {name=l45 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 230.0 -410.0 0 0 {name=l46 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 230.0 -390.0 0 0 {name=l47 sig_type=std_logic lab=DAC_IN}
C {DAC_Buffer.sym} 460 -400 0 0 {name=xXBUFFER}
C {devices/lab_pin.sym} 370.0 -430.0 0 0 {name=l48 sig_type=std_logic lab=DAC_IN}
C {devices/lab_pin.sym} 550.0 -430.0 0 0 {name=l49 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 550.0 -410.0 0 0 {name=l50 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 550.0 -390.0 0 0 {name=l51 sig_type=std_logic lab=IBIAS}
C {devices/lab_pin.sym} 550.0 -370.0 0 0 {name=l52 sig_type=std_logic lab=VOUT}
