v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {DAC_Buffer: generated from the LTspice schematic by tools/gen_xschem.py} -900 -560 0 0 0.4 0.4 {}
C {devices/ipin.sym} -900 -500 0 0 {name=p1 lab=IN}
C {devices/iopin.sym} -900 -470 0 0 {name=p2 lab=VDDA}
C {devices/iopin.sym} -900 -440 0 0 {name=p3 lab=VSS}
C {devices/iopin.sym} -900 -410 0 0 {name=p4 lab=IBIAS}
C {devices/opin.sym} -900 -380 0 0 {name=p5 lab=OUT}
C {Sky_OTA.sym} -500 -400 0 0 {name=xXOTA}
C {devices/lab_pin.sym} -590.0 -430.0 0 0 {name=l1 sig_type=std_logic lab=IN}
C {devices/lab_pin.sym} -590.0 -410.0 0 0 {name=l2 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} -410.0 -430.0 0 0 {name=l3 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} -410.0 -410.0 0 0 {name=l4 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -410.0 -390.0 0 0 {name=l5 sig_type=std_logic lab=IBIAS}
C {devices/lab_pin.sym} -410.0 -370.0 0 0 {name=l6 sig_type=std_logic lab=OUT}
